## zephyr/Kconfig
```kconfig
menuconfig ZOOT
    bool "Zoot Support"
    select COZY
    help
        This option enables the Zoot SUIT library.
```
